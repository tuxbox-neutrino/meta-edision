IMAGE_INSTALL += "pulseaudio"
