#RDEPENDS_${PN}  += "edision-qteglfs-platform"
