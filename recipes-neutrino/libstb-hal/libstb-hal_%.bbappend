FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-video.cpp-remove-deprecated-calls.patch"

